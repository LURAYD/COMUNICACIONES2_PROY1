options:
  parameters:
    author: Comunicaciones II 2026 - Proyecto 1
    comment: |-
      Validacion cruzada (seccion 11 de la guia).
      GNU Radio actua como RECEPTOR de la MISMA forma de onda generada por
      el simulador de Python (io/py_tx_signal.cf32, escrita por
      experiments/exp6_validacion_grc.py). Al ser identico el transmisor y el
      canal, cualquier diferencia de resultado es atribuible al receptor.
    description: Receptor QPSK de GNU Radio sobre la forma de onda de Python
    generate_options: qt_gui
    id: rx_qpsk_desde_python
    output_language: python
    title: RX QPSK sobre senal de Python (Comunicaciones II)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: Ramas del banco polifase del sincronizador de temporizacion
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: |-
      Filtro adaptado interpolado por nfilts,
      como pide el bloque Polyphase Clock Sync.
    value: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, samp_rate/sps, excess_bw, 11*sps*nfilts)
  states: {}
- name: eq_taps
  id: variable
  parameters:
    comment: Numero de taps del ecualizador adaptativo
    value: '21'
  states: {}
- name: eq_mu
  id: variable
  parameters:
    comment: Paso de adaptacion del LMS dirigido por decision
    value: '0.010'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Forma de onda generada por el simulador
      de Python (complex64).
      La escribe exp6_validacion_grc.py.
    file: io/py_tx_signal.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: |-
      Mismo canal que en el escenario simulado.
      Desactivar (noise_voltage=0, taps=[1])
      para comparar solo el receptor.
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.10'
    seed: '2026'
    taps: '[1.0+0.0j]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: |-
      Filtro adaptado + recuperacion de
      temporizacion (equivale al lazo de
      Gardner del receptor de Python).
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.020'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Recuperacion de portadora (equivale al
      PLL dirigido por decision).
    order: '4'
    w: '0.0031'
  states: {}
- name: alg_lms
  id: variable_adaptive_algorithm
  parameters:
    comment: |-
      Algoritmo de adaptacion del ecualizador.
      GNU Radio 3.9 sustituyo los bloques
      lms_dd_equalizer_cc / cma_equalizer_cc por
      esta pareja objeto-algoritmo + ecualizador.
      Opciones de 'type': lms, nlms, cma.
    cons: qpsk_const
    ffactor: '.99'
    step_size: eq_mu
    type: lms
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: alg_lms
    comment: |-
      Ecualizador lineal adaptativo.
      Con training_sequence vacia opera
      dirigido por decision: equivale al
      metodo A del proyecto pero SIN secuencia
      de entrenamiento, que es justo la
      diferencia que se analiza en el informe.
    num_taps: eq_taps
    sps: '1'
    training_start_tag: '"corr_est"'
  states: {}
- name: blocks_file_sink_sym
  id: blocks_file_sink
  parameters:
    comment: |-
      Simbolos ecualizados (complex64).
      El script de Python los sincroniza con
      la trama conocida y calcula la BER.
    file: io/grc_rx_symbols.cf32
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Ecualizado
    name: '"Constelacion tras ecualizacion"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: PSD recibida
    name: '"Densidad espectral de potencia"'
    type: complex
    ymin: '-100'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    alpha1: '0.15'
    grid: 'True'
    gui_hint: 1,0,1,2
    name: '"Diagrama de ojo"'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"time_est"'
    type: complex
    ylabel: Amplitud
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [blocks_file_source_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', digital_linear_equalizer_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_linear_equalizer_0, '0', blocks_file_sink_sym, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
